/*****************************************************************************/
/******************************  Button Pressed  *****************************/
void ICACHE_RAM_ATTR button_pressed() {
  if (digitalRead(button) == LOW) {
    if (startNewButtonCounter == true) {
      startNewButtonCounter = false;
      buttonCounter = 0;
      buttonPressed = true;
    }
    if (millis() - oldButtonPressTimer > 100) {
      buttonCounter++;
    }
  } else {
    oldButtonPressTimer = millis();
  }
}
/******************************  Button Pressed  *****************************/
/*****************************************************************************/


/*****************************************************************************/
/*******************************  Factory Reset  *****************************/
void factory_reset() {
  analogWrite(OrangeLED, 50);
  resetCounter = 0;
  while (digitalRead(button) == LOW) {
    if (LED_BLINK_ON == true) {
      analogWrite(OrangeLED, 0);
      LED_BLINK_ON = false;
    } else {
      analogWrite(OrangeLED, 50);
      LED_BLINK_ON = true;
    }
    resetCounter++;
    if (resetCounter >= 200) {
      analogWrite(OrangeLED, 50);
      // delay(1500);
      resetCounter = 0;
    }
    delay(50);
  }
  analogWrite(OrangeLED, 0);
  buttonPressed = false;
}
/*******************************  Factory Reset  *****************************/
/*****************************************************************************/


/*****************************************************************************/
/*******************************  Turn Off LED  ******************************/
void TurnOffLEDs() {
  blinkerOrangeLED.detach();
  analogWrite(OrangeLED, 0);
  ledFade = true;
}
/*******************************  Turn Off LED  ******************************/
/*****************************************************************************/


/*****************************************************************************/
/********************************  toggle LED  *******************************/
void changeStateOrangeLED() {
  ledFade = false;
  if (LED_BLINK_ON == true) {
    analogWrite(OrangeLED, 0);
    LED_BLINK_ON = false;
  } else {
    analogWrite(OrangeLED, 50);
    LED_BLINK_ON = true;
  }
}
/********************************  toggle LED  *******************************/
/*****************************************************************************/

/*****************************************************************************/
/*****************************  10 Seconds flag  *****************************/
void sendDataVoid() {
  temperature_data_sent = false;
}
/*****************************  10 Seconds flag  *****************************/
/*****************************************************************************/

/*****************************************************************************/
/*****************************  10 Seconds flag  *****************************/
void readSensorVoid() {
  read_sensors();
}
/*****************************  10 Seconds flag  *****************************/
/*****************************************************************************/


/*****************************************************************************/
/****************************** float rounding  ******************************/
double roundFloat(double value) {
  return (int)(value * 10 + 0.5) / 10.0;
}
/****************************** float rounding  ******************************/
/*****************************************************************************/
